#include 		<P16F877A.INC>
__config			H'3F31'

DURUM		EQU		0X0021

ORG			0X0000
GOTO		AYAR

ORG			0X0009	
GOTO		MAIN

AYAR
	CLRF		PORTB
	BSF			STATUS,RP0
	MOVLW		0X06
	MOVWF		ADCON0
	BSF			TRISA,0
	CLRF		TRISB
	BCF			STATUS,RP0
	GOTO		MAIN

MAIN
	DONGU
		BTFSS		PORTA,0
		GOTO		$-1
		COMF		DURUM,F
		BTFSC		DURUM,0
		BSF			PORTB,0
		BTFSS		DURUM,0
		BCF			PORTB,0
		BTFSC		PORTA,0
		GOTO		$-1
		GOTO		DONGU

END